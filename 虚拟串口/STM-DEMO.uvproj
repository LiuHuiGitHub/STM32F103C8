# Keil uVision project STM-DEMO.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\App;.\Driver;.\FWlib\CMSIS\startup;.\FWlib\inc;.\FWlib\src;.\uCOS-II\Source;.\uCOS-II\Ports;.\USER;.\FWlib;.\uCOS-II;.\Driver\LCD_Driver;.\Driver\Touch;.\Hwa;.\System;.\App\app_can;.\UserLib;.\App\app_can\CanMsgCreate\Debug;.\System\Core;.\USB\lib;.\USB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c MyLibrary.c stm32f10x_it.c system.c
  group Hwa
    ./Hwa/: hwa_key.c
  group Driver
    ./Driver/: drive_flash.c drive_e2.c drive_ir.c drive_usart.c
  group System
    ./System/: sys_adc.c sys_rtc.c sys_pwm.c sys_dac.c sys_clock.c sys_core.c sys_count.c sys_cpu.c sys_key.c sys_usart.c sys_tim.c sys_exti.c
  group CMSIS
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./FWlib/CMSIS/: core_cm3.c system_stm32f10x.c
    ./FWlib/CMSIS/startup/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group UserLib
    ./UserLib/: uLib_PID.c uLib_mbSlave.c uLib_Queue.c uLib_crc16rtu.c uLib_mbSlave_Itf.c
  group USB
    ./USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ./USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Notes
    ./Notes/: Notes.txt
